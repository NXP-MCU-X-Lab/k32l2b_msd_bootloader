# Keil uVision project k32l2b.uvproj, settings and files
target k32l2b_bl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL36Z256xxx4 NXP
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: k32l2b_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=246, MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, INTERFACE_KL26Z, CPU_MKL26Z128VLH4, DAPLINK_HIC_ID=0x97969901, FLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0, FLASH_DRIVER_IS_FLASH_RESIDENT=1, DAPLINK_NO_ASSERT_FILENAMES CPU_K32L2B31VLH0A
  c misc: --gnu --c99
  c include: ..\..\..\source\usb; ..\..\..\source\daplink; ..\..\..\source\daplink\bootloader; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\settings; ..\..\..\source\rtos; ..\..\..\source\hic_hal\freescale\kl26z; ..\..\..\source\hic_hal\freescale\kl26z\MKL26Z4; ..\..\..\projectfiles\uvision\kl26z_bl
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=246,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DINTERFACE_KL26Z,-DCPU_MKL26Z128VLH4,-DDAPLINK_HIC_ID=0x97969901,-DFLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0,-DFLASH_DRIVER_IS_FLASH_RESIDENT=1,-DDAPLINK_NO_ASSERT_FILENAMES
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\..\..\source\hic_hal\freescale\kl26z"
  group board
    ../../../source/board/: k32l2b_bl.c
  group daplink_bl
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c info.c RTX_Config.c util.c validation.c
    ../../../source/daplink/bootloader/: daplink.c main.c SVC_Table.s
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h target_config.h target_reset.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h version_git.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/hic_hal/freescale/kl26z/: DAP_config.h daplink_addr.h IO_Config.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/hic_hal/freescale/kl26z/MKL26Z4/: fsl_device_registers.h MKL26Z4.h MKL26Z4_features.h system_MKL26Z4.h
    ../../../source/daplink/bootloader/: main.h
    ../../../source/usb/: rl_usb.h usb.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/rtos/: rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/daplink/settings/: settings.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group fsl_flash_driver
    ../../../source/hic_hal/freescale/iap/: FlashDev.c FlashPrg.c fsl_flash.c
  group hic_hal
    ../../../source/hic_hal/freescale/kl26z/: gpio.c read_uid.c uart.c usb_config.c
    ../../../source/hic_hal/freescale/: usbd_kinetis.c
    ../../../source/hic_hal/freescale/kl26z/MKL26Z4/: system_K32L2B31A.c
    ../../../source/hic_hal/freescale/kl26z/armcc/: startup_K32L2B31A.s
  group rtos
    ../../../source/rtos/cm0/: HAL_CM1.c
    ../../../source/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom_stub.c
  group usb
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
